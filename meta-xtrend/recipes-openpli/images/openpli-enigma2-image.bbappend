ENIGMA2_PLUGINS:append = "\    
	enigma2-plugin-extensions-backupsuite \
	enigma2-plugin-extensions-vzaphistory \
	"

ENIGMA2_PLUGINS:remove = "\
	enigma2-plugin-extensions-ppanel \
    "
    

